# Keil uVision project USB2CAN.uvproj, settings and files
target STM32F103B (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USB2CAN_SoftUart +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3
  c define: VECT_TAB_FLASH
  c include: ..\Source;..\library\inc;..\Project
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group RVMDK
    ../Source/: STM32F10x.s
    ./: cortexm3_macro.s
  group User
    ../Source/: main.c Tasks.c USB2CAN_Func.c
  group RL-ARM
    ../Source/: RTX_CAN.c RTX_Config.c CAN_Hw.c
  group User_Driver
    ../Source/: CQueue.c USB2CAN_BSL.c USART.c Flash.c SoftUart.c
  group FWLib
    ../library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Doc
    ./: readme.txt
